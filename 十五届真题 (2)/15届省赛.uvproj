# Keil uVision project 15届省赛.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 模拟题1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\common;.\drive;.\user
  group user
    ./: STARTUP.A51
    ./user/: main.c
  group common
    ./common/: su_common_typedef.h
  group drive
    ./drive/: Key.c Key.h Seg.c Seg.h ds1302.h ds1302.c iic.c iic.h Led.c Led.h
