# Keil uVision project lanqiao13.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lanqiao13 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drive;.\common;.\user
  group user
    ./: STARTUP.A51
    ./user/: main.c
  group common
    ./common/: su_common_typedef.h
  group drive
    ./drive/: key.c key.h seg.c seg.h ds1302.c ds1302.h onewire.c onewire.h led.c led.h
